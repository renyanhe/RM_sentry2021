# Keil uVision project RM2020.uvprojx, settings and files
target RM2020 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2020 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --gnu -Dlittle_endian
  c include: ..\MAKOS;..\MAKOS\includes;..\MAKOS\kernel;..\MAKOS\migration;..\STM32F4;..\STM32F4\inc;..\system;..\user\device;..\user;..\user\device\mpu;..\user\driver;..\user\user_other;..\user\user_app;..\STM32F4\DSP_LIB\Include;..\user\base_app;..\sentry;..\math;..\sentry;..\sentry
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../user/: main.c
    ../user/base_app/: headfile.h
  group sentry
    ../sentry/: sentry_pull.c sentry_friction.c sentry_ultrasonic.c sentry_classis.c sentry_holder.c sentry_vision.c Kalman_filtering.c amplitude_limiting_and_LPF.c
  group user/app
    ../user/user_app/: task_init.c
  group user/other
    ../user/user_other/: user_can.c user_usart.c communicate.c correct_ctrl.c holder_pid.c pos_ctrl.c pid.c UI.c
  group base/app
    ../user/base_app/: task_judge.c task_remote.c task_nimin.c task_led.c task_UI.c task_Ano.c task_mpu.c
  group device
    ../user/device/: flash_data.c keyboard.c uart_dma.c dbus.c timer.c can.c led.c oled.c PWM.c usart.c iic_xuni.c rng_led.c imu_data_decode.c imu_packet.c mpu.c HC_ultrasonic.c
  group driver
    ../user/driver/: communicate_nimin.c irq_dead_check.c judgement_info.c stm32_flash.c nimin_info.c mak_filter.c data_fifo.c mak_pid.c protocol.c UI_lib.c
  group MAKOS
    ../MAKOS/migration/: makos_pendsv.c makos_critical.c makos_tick.c
    ../MAKOS/includes/: makos_doublelist.c makos_F2S.c
    ../MAKOS/kernel/: makos_memory.c makos_mutex.c makos_semaphore.c makos_pipe.c makos_task.c makos_system.c makos_message.c makos_schedule.c makos_tick_handle.c makos_dnode_queue.c makos_print.c makos_idle.c makos_resolver.c makos_irq_handle.c makos_record.c mak_print.c
  group STM32F4
    ../STM32F4/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40xx.s
    ../STM32F4/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rng.c
    ../STM32F4/DSP_LIB/: arm_cortexM4lf_math.lib
  group DOC
    ../DOC/: makos简单说明.txt 裁判系统API.txt UI_userguaide.txt 蓝牙app.txt
    ../../: ANO.txt readme.txt
  group math
    ../math/: arm_matrix_example_f32.c math_helper.c
